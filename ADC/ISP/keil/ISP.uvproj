# Keil uVision project ISP.uvproj, settings and files
target ISP (MCS-51)
  device: N76E885 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0xFF) CLOCK(25000000)
  output: ISP +hex
  c flags: Optimize=1 SizeSpeed=1
  c include: ..\user
  group user
    ../user/: main.c UART0_transfer.c STARTUP.A51
