# Keil uVision project ADC.uvproj, settings and files
target ADC (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: headset +hex
  c flags: Optimize=6 SizeSpeed=1
  c define: FOSC_160000
  c include: .\usr
  group Optimizing
    ./usr/: main.c delay.c common.c
