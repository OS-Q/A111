# Keil uVision project main.uvproj, settings and files
target Qitas (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: main +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\user
  group user
    ../user/: main.c uart.c WS281X.c dht11.c
  group common
    ../user/: common.c delay.c
