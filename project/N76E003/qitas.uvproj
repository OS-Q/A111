# Keil uVision project qitas.uvproj, settings and files
target ADC (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: adc +hex
  c flags: Optimize=6 SizeSpeed=1
  c define: FOSC_160000
  c include: .\user;.\N76E003
  group user
    ./user/: main.c adc.c delay.c common.c STARTUP.A51
